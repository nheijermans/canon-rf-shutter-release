# IAR project shutter-release.ewp, settings and files
configuration remoteside (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500; REMOTE_SIDE
  ICC430.IExtraOptions: -f"config\config_ED.dat"; -f"config\nwk-config.dat"
  ICC430.newCCIncludePaths: bsp; bsp\drivers; bsp\boards\EZ430RF; mrfi; simpliciti\nwk; simpliciti\nwk_applications
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration cameraside (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500; CAMERA_SIDE
  ICC430.IExtraOptions: -f"config\config_AP.dat"; -f"config\nwk-config.dat"
  group app
    app/: cameraside.c main.c remoteside.c vlo_rand.h vlo_rand.s43
  group Configuration
    config/: config_AP.dat config_ED.dat nwk-config.dat
  group SimpliciTI/bsp
    bsp/: bsp.c bsp.h bsp_macros.h
  group SimpliciTI/mrfi
    mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group SimpliciTI/nwk
    simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group SimpliciTI/nwk_applications
    simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_pll.h nwk_security.c nwk_security.h
